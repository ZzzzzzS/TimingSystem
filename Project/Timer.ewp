# IAR project Timer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 NXP MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MK60DN512VLQ10_cm4; CPU_MK60DN512VLQ10; FSL_RTOS_BM; SDK_CORE_ID_CORE0; SDK_OS_BAREMETAL
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: CMSIS; board; drivers; startup; utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: cppproject_templates.out
  ILINK.IlinkIcfFile: MK60DN512xxx10_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK60DN512VLQ10_cm4; CPU_MK60DN512VLQ10; FSL_RTOS_BM; SDK_CORE_ID_CORE0; SDK_OS_BAREMETAL
  ICCARM.CCOptLevel: 3
  group (top)
    ./: MK60DN512xxx10_flash.icf
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h fsl_device_registers.h MK60D10.h MK60D10_features.h system_MK60D10.c system_MK60D10.h
  group drivers
    drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_cmt.c fsl_cmt.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.c fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rnga.c fsl_rnga.h fsl_rtc.c fsl_rtc.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_sdhc.c fsl_sdhc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_sysmpu.c fsl_sysmpu.h fsl_tsi_v2.c fsl_tsi_v2.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
  group source
    source/: data.cpp data.h handler.cpp main.cpp OLED.cpp OLED.h system.cpp system.h
  group startup
    startup/: startup_MK60D10.s
  group utilities
    utilities/: fsl_debug_console.c fsl_debug_console.h fsl_notifier.c fsl_notifier.h fsl_shell.c fsl_shell.h
