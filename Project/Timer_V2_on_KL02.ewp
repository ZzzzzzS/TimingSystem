# IAR project Timer_V2_on_KL02.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL02Z32xxx4 NXP MKL02Z32xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL02Z32VFM4_cm0plus; CPU_MKL02Z32VFM4; FSL_RTOS_BM; SDK_CORE_ID_CORE0; SDK_OS_BAREMETAL
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: CMSIS; board; drivers; startup; utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: cppproject_templates.out
  ILINK.IlinkIcfFile: MKL02Z32xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL02Z32VFM4_cm0plus; CPU_MKL02Z32VFM4; FSL_RTOS_BM; SDK_CORE_ID_CORE0; SDK_OS_BAREMETAL
  ICCARM.CCOptLevel: 3
  group (top)
    ./: MKL02Z32xxx4_flash.icf
  group board
    board/: board.c board.h clock_config.c clock_config.h cppproject_templates.dni cproject_templates.dni pin_mux.c pin_mux.h RTE_Device.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0plus.h core_cmFunc.h core_cmInstr.h core_cmSimd.h fsl_device_registers.h MKL02Z4.h MKL02Z4_features.h system_MKL02Z4.c system_MKL02Z4.h
  group drivers
    drivers/: Driver_CAN.h Driver_Common.h Driver_ETH.h Driver_ETH_MAC.h Driver_ETH_PHY.h Driver_Flash.h Driver_I2C.h Driver_MCI.h Driver_NAND.h Driver_SAI.h Driver_SPI.h Driver_USART.h Driver_USB.h Driver_USBD.h Driver_USBH.h fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_cop.c fsl_cop.h fsl_flash.c fsl_flash.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_cmsis.c fsl_i2c_cmsis.h fsl_lpsci.c fsl_lpsci.h fsl_lpsci_cmsis.c fsl_lpsci_cmsis.h fsl_lptmr.c fsl_lptmr.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_spi.c fsl_spi.h fsl_spi_cmsis.c fsl_spi_cmsis.h fsl_tpm.c fsl_tpm.h
  group source
    source/: data.cpp data.h handler.cpp main.cpp OLED.cpp OLED.h system.cpp system.h
  group startup
    startup/: startup_MKL02Z4.s
  group utilities
    utilities/: fsl_debug_console.c fsl_debug_console.h fsl_notifier.c fsl_notifier.h fsl_shell.c fsl_shell.h
